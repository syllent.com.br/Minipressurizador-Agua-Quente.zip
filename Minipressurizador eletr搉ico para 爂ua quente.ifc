Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: f31c2926-91f3-4c07-8868-4fc9878b25e6, VersionGUID: fc051e47-af6c-41d4-893a-f47c13fa63d4, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordenadas compartilhadas, ProjectSite: Terreno padrão]
File name: Minipressurizador eletrônico para água quente.ifc
Time: 2025-02-02T15:43:32-03:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.0.13 (PTB) - IFC 24.3.0.13

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Nível:Cabeça de 8 mm (6)
Name | LongName | Elevation (mm)
Sapata B.O. | Sapata B.O. | -4600
Sapata T.O. | Sapata T.O. | -4300
Laje T.O. | Laje T.O. | -4000
Parede da fundação T.O. | Parede da fundação T.O. | -300
Nível 1 | Nível 1 | 0
Nível 2 | Nível 2 | 4000

# IfcBuildingElementProxy: Minipressurizador eletrônico para água quente:350W - 120v, Minipressurizador eletrônico para água quente:350W - 120v:318976
In: Nível 1
Type - Material: Plástico vermelho - Syllent, Plástico prego - Syllent, Latão - Syllent
Type - Pset_ManufacturerTypeInformation - Manufacturer: Syllent
Material: Latão - Syllent, Aço Inox, Plástico amarelo - Syllent, Vidro, Plástico prego - Syllent, Branco do manômetro, Plástico vermelho - Syllent
Pset_BuildingElementProxyCommon - Reference: 350W - 120v; sets with these values: 2

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
OutPort_318976_2 | SOURCE
InPort_318976_3 | SINK
